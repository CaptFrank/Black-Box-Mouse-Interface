<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ez430_chronos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Versions</name>
      <member>
        <project>ez430_chronos</project>
        <configuration>433MHz - Limited IAR Kickstart (Other regions)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>433MHz - Unrestricted IAR Workbench (Other regions)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>868MHz - Limited IAR Kickstart (Europe)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>868MHz - Unrestricted IAR Workbench (Europe)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>915MHz - Limited IAR Kickstart (USA)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>915MHz - Unrestricted IAR Workbench (USA)</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Limited Versions</name>
      <member>
        <project>ez430_chronos</project>
        <configuration>433MHz - Limited IAR Kickstart (Other regions)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>868MHz - Limited IAR Kickstart (Europe)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>915MHz - Limited IAR Kickstart (USA)</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Unrestricted Versions</name>
      <member>
        <project>ez430_chronos</project>
        <configuration>433MHz - Unrestricted IAR Workbench (Other regions)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>868MHz - Unrestricted IAR Workbench (Europe)</configuration>
      </member>
      <member>
        <project>ez430_chronos</project>
        <configuration>915MHz - Unrestricted IAR Workbench (USA)</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


